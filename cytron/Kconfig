## cytron/Kconfig
```kconfig
menuconfig DRIVERS_CYTRON
	bool "cytron"
	default n
	---help---
		Enable support for cytron
```
